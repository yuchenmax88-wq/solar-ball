## firmware/sdkconfig.defaults
```kconfig
CONFIG_I2C_SUPPRESS_DEPRECATE_WARN=y
# ESP32-WROOM-32 has 4MB flash (fix mismatch warning)
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
